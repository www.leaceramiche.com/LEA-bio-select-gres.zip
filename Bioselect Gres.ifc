Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement[Architecture]
File name: F:/BIM PGR/BIM LEA/BIOSELECT/Bioselect Gres.ifc
Time: 2021-01-29T13:00:03
Author: Architect
Organization: Nemetschek Vectorworks, Inc.
Written by: Vectorworks Architect 2021 SP2 R1 (Build 574483) (64-Bit) by Vectorworks, Inc.
Made in: Windows

# IfcSite, Sito standard
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0

# IfcBuilding, Edificio standard
Pset_BuildingCommon - SprinklerProtection: no; SprinklerProtectionAutomatic: no; NumberOfStoreys: 1; IsLandmarked: no

# IfcBuildingStorey, Piano 1
In: Edificio standard
Elevation: 0 mm
Pset_BuildingStoreyCommon - EntranceLevel: no; AboveGround: yes; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2

# IfcCovering: full body porcelain stoneware (UGL) (23)
In: Piano 1
Description: Porcelain stoneware tiles; PredefinedType: USERDEFINED; Material: Default
OtherThecnicalFeatures - AntibacterialProperties: Protect - test report available; ApparentDensity: 2,3 - 2,5 g/cm3; ChemicalResistance: LA, HA RESISTANT; CompressionResistance: n/a; CrazingResistance: Pass; DeepAbrasionResistance: 145 mm3; DimensionsLengthAndWidth: ± 0,3 %, max ± 1 mm; DimensionsRectangularity: ± 0,3 %, max ± 1,5 mm; DimensionsStraightness: ± 0,3 %, max ± 0,8 mm; DimensionsSurfaceFlatness: ± 0,4 %, max ± 1,8 mm; DimensionsThickness: ± 5 % ± 0,5mm; ElectricalConductivity: n/a; FrostResistance: Resistant; HardnessMohsScale: n/a; ImpactResistance: n/a; Light ReflectanceValueLRV: On request; LightAndColourFastness: Pass; LinearThermalExpansion: α ≤ 7·10-6 °C-1; ModulusOfRupture: 50 N/mm2; MoistureExpansion: n/a; PhotocatalyticProperties: n/a; StainsResistance: 5 RESISTANT; SurfaceAbrasionResistance: n/a; SurfaceQuality: n/a; ThermalConductivity: 1,3 W/m °K; TotalPorosity: n/a; WaterAbsorption: 0,05 %
EnvironmentalSustainability - AsbestosFreeMaterial: yes; CAMCompliantDeclaration: On request (EPD); Ecolabel UE: no; EcolabelCertification: n/a; EMASCertification/Document: https://www.leaceramiche.it/download; EnvironmentalProductDeclarationEPD: yes; EPDDocument: On request; EPDType: Product-Specific Type III EPD; FicheDeDéclarationEnvironnementaleEtSanitaireFDESCertification: n/a; FormaldehydeFreeMaterial: yes; HealthProductDeclarationHPDCertification/self declaration: On request; ISO45001Certification: n/a; ISO50001Certification: n/a; ISO9001Certification: https://www.leaceramiche.it/download; RawMaterialSourceAndExtractionDocument: On request; REACHCompliant: yes; RecyclableProductPackaging: yes; RecycledContentPreconsumerCertification: https://www.leaceramiche.it/download; SolarReflectance_After3YearValue: On request; SolarReflectance_InitialValue: On request; SolarReflectanceCertification: n/a; SolarReflectanceIndexSRICertification: On request; VOCIndoorAirQualityCertification: On request; ZeroVOCMineralBasedProduct: yes
DoP&ProductCertification - BondStrengthAdhesion: NPD; CEMarking: yes; CertificateNumber: n/a; DeclarationPerformanceNumber: DOP001LEA; DurabilityExternalUseFreezeThawResistance: Passed; DurabilityForInternalUse: Passed; HarmonizedTechnicalSpecification: EN 14411:2012; Intended Use: Ceramic tiles for flooring and wall finishes, internal and external applications.; NameAndIdentificationNumberOfNotifiedLaboratory: n/a; ReactionToFire: Class A1 (wall) ; Class A1fl (floor); ReleaseOfDangerousSubstanceCadmium: NPD; ReleaseOfDangerousSubstanceLead: NPD; SlipperinessBCRA_Tribometer: μ > 0,40; SlipperinessBOT3000_Tribometer: DCOF ≥ 0.42; SlipperinessDIN51131_Tribometer: n/a; SlipperinessENV12633_PendulumTester: n/a; SlipperinessXPCENTS16165_RampTest: n/a; SystemOfAssessmentAndVerificationOfCostancyOfPperformance: System 4; Tactility: NPD; TensileStrengthOrModulusOfRupture: 50 N/mm2; ThermalShockResistance: Pass; UNIMark: yes; UNIMarkCertification: On request; UniqueIdentificationCodeOfTheProductType: Dry-pressed ceramic tiles,with water absorption Eb<0,5%; UPECmark: no; UPECMarkCertification: n/a
COBie_ServiceLife - ExpectedLife: 50
COBie_EconomicImpactValues - ReplacementCost: 0
COBie_Component - InstallationDate: 31/12/1900 23:59:59; WarrantyStartDate: n/a; TagNumber: n/a; AssetIdentifier: n/a
Pset_CoveringFlooring - HasNonSkidSurface: yes; HasAntiStaticSurface: no
Pset_Condition - AssessmentDate: 31/12/1900 23:59:59; AssessmentCondition: n/a; AssessmentDescription: n/a
Pset_CoveringCommon - Reference: full body porcelain stoneware (UGL); AcousticRating: n/a; FlammabilityRating: Class A1 (wall) ; Class A1fl (floor); FragilityRating: n/a; Combustible: no; SurfaceSpreadOfFlame: Class A; IsExternal: yes; FireRating: Class A1 (wall) ; Class A1fl (floor)
COBie_Asset - AssetType: Fixed
COBie_Specification - Shape: Rectangle; Grade: n/a; Material: Porcelain stoneware tile; Constituents: n/a; Features: n/a; AccessibilityPerformance: n/a; CodePerformance: n/a; SustainabilityPerformance: n/a
COBie_Warranty - WarrantyGuarantorParts: n/a; WarrantyDurationParts: 0; WarrantyGuarantorLabor: n/a; WarrantyDurationLabor: 0; WarrantyDescription: n/a
Pset_ManufacturerTypeInformation - GlobalTradeItemNumber: n/a; Manufacturer: Lea Ceramiche (Panariagroup Industrie Ceramiche S.p.A.); ProductionYear: n/a
Pset_EnvironmentalImpactIndicators - Reference: full body porcelain stoneware (UGL); FunctionalUnitReference: 1 mq (m2); Unit: 1 mq (m2); LifeCyclePhase: Manufacture; ExpectedServiceLife: 50 s; TotalPrimaryEnergyConsumptionPerUnit: 242.3; WaterConsumptionPerUnit: 0.0549 m3; HazardousWastePerUnit: 0.000603 g; NonHazardousWastePerUnit: 1.36 g; ClimateChangePerUnit: 12 g; AtmosphericAcidificationPerUnit: 0.0241 g; RenewableEnergyConsumptionPerUnit: 47.3; NonRenewableEnergyConsumptionPerUnit: 195; ResourceDepletionPerUnit: 0.000075 g; InertWastePerUnit: 0 g; RadioactiveWastePerUnit: 0.00326 g; StratosphericOzoneLayerDestructionPerUnit: 0 g; PhotochemicalOzoneFormationPerUnit: 0.00183 g; EutrophicationPerUnit: 0.0037 g
Pset_EnvironmentalImpactValues - TotalPrimaryEnergyConsumption: 0; WaterConsumption: 0 m3; HazardousWaste: 0 g; NonHazardousWaste: 0 g; ClimateChange: 0 g; AtmosphericAcidification: 0 g; RenewableEnergyConsumption: 0; NonRenewableEnergyConsumption: 0; ResourceDepletion: 0 g; InertWaste: 0 g; RadioactiveWaste: 0 g; StratosphericOzoneLayerDestruction: 0 g; PhotochemicalOzoneFormation: 0 g; Eutrophication: 0 g; LeadInTime: 0; Duration: 0; LeadOutTime: 0
Pset_ServiceLife - ServiceLifeDuration: 50; MeanTimeBetweenFailure: n/a
Pset_Warranty - WarrantyIdentifier: n/a; WarrantyStartDate: 31/12/1900 23:59:59; WarrantyEndDate: 31/12/1900 23:59:59; IsExtendedWarranty: no; WarrantyPeriod: n/a; WarrantyContent: n/a; PointOfContact: n/a; Exclusions: n/a
COBie - BarCode: n/a; Category: Pr_35_93_96_19:Ceramic tiles; Description: Wood Effect; DurationUnit: Year; Manufacturer: Lea Ceramiche (Panariagroup Industrie Ceramiche S.p.A.); ModelNumber: n/a; SerialNumber: n/a; WarrantyDurationUnit: Year
Name | BreakingStrength | SlipperinessBS7976-2_PendulumTester | SlipperinessDIN51097_RampBarefoot | SlipperinessDIN51130_RampWithOil | Pset_CoveringCommon, Finish = COBie_Specification, Finish | ThermalTransmittance (W/K/m2) | NominalLength (mm) | NominalWidth (mm) | NominalHeight (mm) | Size | Color | ArticleNumber | Pset_ManufacturerTypeInformation, ModelReference = COBie, ModelReference | ModelLabel | Name
BioSelect Oak Vanilla Nat Ret 20x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 200 | 1200 | 9.5 | 200x1200x9.5 mm | Oak Vanilla | LG7B330 | Bio Select | Oak Vanilla Nat Ret | Oak Vanilla Nat Ret 20x120
BioSelect Oak Vanilla Nat Ret 30x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 300 | 1200 | 9.5 | 300x1200x9.5 mm | Oak Vanilla | LG6B330 | Bio Select | Oak Vanilla Nat Ret | Oak Vanilla Nat Ret 30x120
BioSelect Oak Vanilla Nat Ret 30x180 | 2500 N | na | n/a | R10 | Natural Rectified | 123.8 | 300 | 1800 | 10.5 | 300x1800x10.5 mm | Oak Vanilla | LGIB330 | Bio Select | Oak Vanilla Nat Ret | Oak Vanilla Nat Ret 30x120
BioSelect Oak Ginger Nat Ret 20x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 200 | 1200 | 9.5 | 200x1200x9.5 mm | Oak Ginger | LG7B360 | Bio Select | Oak Ginger Nat Ret | Oak Ginger Nat Ret 20x120
BioSelect Oak Ginger Nat Ret 30x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 300 | 1200 | 9.5 | 300x1200x9.5 mm | Oak Ginger | LG6B360 | Bio Select | Oak Ginger Nat Ret | Oak Ginger Nat Ret 30x120
BioSelect Oak Ginger Nat Ret 30x180 | 2500 N | na | n/a | R10 | Natural Rectified | 123.8 | 300 | 1800 | 10.5 | 300x1800x10.5 mm | Oak Ginger | LGIB330 | Bio Select | Oak Ginger Nat Ret | Oak Ginger Nat Ret 30x120
BioSelect Oak Natural Nat Ret 20x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 200 | 1200 | 9.5 | 200x1200x9.5 mm | Oak Natural | LG7B310 | Bio Select | Oak Natural Nat Ret | Oak Natural Nat Ret 20x120
BioSelect Oak Natural Nat Ret 30x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 300 | 1200 | 9.5 | 300x1200x9.5 mm | Oak Natural | LG6B310 | Bio Select | Oak Natural Nat Ret | Oak Natural Nat Ret 30x120
BioSelect Oak Natural Nat Ret 30x180 | 2500 N | na | n/a | R10 | Natural Rectified | 123.8 | 300 | 1800 | 10.5 | 300x1800x10.5 mm | Oak Natural | LGIB310 | Bio Select | Oak Natural Nat Ret | Oak Natural Nat Ret 30x120
BioSelect L2 Oak Natural Grip Ret 30x120 | 13600 N | PTV 36+Wet (Sl. 96 – Sl. 55) | A+B+C | R11 | Grip Rectified | 65 | 300 | 1200 | 20 | 300x1200x20 mm | Oak Natural | LG4B310 | Bio Select L2 | Oak Natural Grip Ret | Oak Natural Grip Ret 30x120
BioSelect Oak Ash Nat Ret 20x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 200 | 1200 | 9.5 | 200x1200x9.5 mm | Oak Ash | LG7B300 | Bio Select | Oak Ash Nat Ret | Oak Ash Nat Ret 20x120
BioSelect Oak Ash Nat Ret 30x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 300 | 1200 | 9.5 | 300x1200x9.5 mm | Oak Ash | LG6B300 | Bio Select | Oak Ash Nat Ret | Oak Ash Nat Ret 30x120
BioSelect Oak Ash Nat Ret 30x180 | 2500 N | na | n/a | R10 | Natural Rectified | 123.8 | 300 | 1800 | 10.5 | 300x1800x10.5 mm | Oak Ash | LGIB300 | Bio Select | Oak Ash Nat Ret | Oak Ash Nat Ret 30x120
BioSelect Oak Cloves Nat Ret 20x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 200 | 1200 | 9.5 | 200x1200x9.5 mm | Oak Cloves | LG7B320 | Bio Select | Oak Cloves Nat Ret | Oak Cloves Nat Ret 20x120
BioSelect Oak Cloves Nat Ret 30x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 300 | 1200 | 9.5 | 300x1200x9.5 mm | Oak Cloves | LG6B320 | Bio Select | Oak Cloves Nat Ret | Oak Cloves Nat Ret 30x120
BioSelect Oak Cloves Nat Ret 30x180 | 2500 N | na | n/a | R10 | Natural Rectified | 123.8 | 300 | 1800 | 10.5 | 300x1800x10.5 mm | Oak Cloves | LGIB320 | Bio Select | Oak Cloves Nat Ret | Oak Cloves Nat Ret 30x120
BioSelect L2 Oak Cloves Grip Ret 30x120 | 13600 N | PTV 36+Wet (Sl. 96 – Sl. 55) | A+B+C | R11 | Grip Rectified | 65 | 300 | 1200 | 20 | 300x1200x20 mm | Oak Cloves | LG4B320 | Bio Select L2 | Oak Cloves Grip Ret | Oak Cloves Grip Ret 30x120
BioSelect Walnut Tobacco Nat Ret 20x120 | 2200 N | na | n/a | R9 | Natural Rectified | 136 | 200 | 1200 | 9.5 | 200x1200x9.5 mm | Walnut Tobacco | LG7B350 | Bio Select | Walnut Tobacco Nat Ret | Walnut Tobacco Nat Ret 20x120
BioSelect Walnut Tobacco Nat Ret 30x120 | 2200 N | na | n/a | R9 | Natural Rectified | 136 | 300 | 1200 | 9.5 | 300x1200x9.5 mm | Walnut Tobacco | LG6B350 | Bio Select | Walnut Tobacco Nat Ret | Walnut Tobacco Nat Ret 30x120
BioSelect Walnut Tobacco Nat Ret 30x180 | 2500 N | na | n/a | R9 | Natural Rectified | 123.8 | 300 | 1800 | 10.5 | 300x1800x10.5 mm | Walnut Tobacco | LGIB350 | Bio Select | Walnut Tobacco Nat Ret | Walnut Tobacco Nat Ret 30x120
BioSelect Walnut Cinnamon Nat Ret 20x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 200 | 1200 | 9.5 | 200x1200x9.5 mm | Walnut Cinnamon | LG7B340 | Bio Select | Walnut Cinnamon Nat Ret | Walnut CinnamonNat Ret 20x120
BioSelect Walnut Cinnamon Nat Ret 30x120 | 2200 N | na | n/a | R10 | Natural Rectified | 136 | 300 | 1200 | 9.5 | 300x1200x9.5 mm | Walnut Cinnamon | LG6B340 | Bio Select | Walnut Cinnamon Nat Ret | Walnut Cinnamon Nat Ret 30x120
BioSelect Walnut Cinnamon Nat Ret 30x180 | 2500 N | na | n/a | R10 | Natural Rectified | 123.8 | 300 | 1800 | 10.5 | 300x1800x10.5 mm | Walnut Cinnamon | LGIB340 | Bio Select | Walnut Cinnamon Nat Ret | Walnut Cinnamon Nat Ret 30x120
